# Keil uVision project sauna.uvproj, settings and files
target sauna (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sauna +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group START
    ../startup/: startup_stm32f10x_cl.s
  group init
    ../init/: main.c stm32f10x_it.c system_stm32f10x.c Delay.c CONFIG.c
  group FWlib
    ../FWlib/SRC/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_flash.c
  group Driver
    ../Driver/: tty.c usart.c 24l01.c
  group include
    ../includes/: head.c
  group UCOS_CORE
    ../kernel/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS_CONFIG
    ../kernel/CONFIG/: includes.h os_cfg.h
  group UCOS_PORT
    ../kernel/CPU/: os_cpu_c.c os_dbg.c os_dbg_r.c os_cpu_a.asm
  group APP
    ../APP/: task.c task.h task2.c
